# Keil uVision project joint-sync-test.uvprojx, settings and files
target JointSyncTest (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: joint-sync-test +hex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\vendor\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Camera pulse test
    ./: main.c rmc.c
    ./vendor/src/: misc.c startup_stm32f10x_hd.s stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c system_stm32f10x.c stm32f10x_usart.c
